DESCRIPTION = "DirtyDonki 28.2 East"

SETTINGS_FILENAME = "enigma2-plugin-settings-donki-uk"

include donki.inc
