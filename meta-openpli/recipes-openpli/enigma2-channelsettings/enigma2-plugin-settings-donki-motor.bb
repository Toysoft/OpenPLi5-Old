DESCRIPTION = "Dirty Donki Motor"

SETTINGS_FILENAME = "enigma2-plugin-settings-donki-motor"

include donki.inc
